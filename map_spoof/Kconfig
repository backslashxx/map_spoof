## map_spoof/Kconfig
```kconfig
menu "reboot"

config MAP_SPOOF
	bool "basic map spoof"
	default y
	help
	  zeroes

endmenu
```
